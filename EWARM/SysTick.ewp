# IAR project SysTick.ewp, settings and files
configuration SysTick (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx
  ICCARM.CCIncludePath2: ..\; ..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\Libraries\CMSIS\ST\STM32F4xx\Include; ..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32F4-Discovery; ..\custom_libs\LCD; ..\custom_libs\Delay; ..\custom_libs\GPIO; ..\custom_libs\USART
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SysTick.srec
  ILINK.IlinkOutputFile: SysTick.out
  ILINK.IlinkIcfFile: stm32f4xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Custom_TM_Libs/Delay
    ../custom_libs/Delay/: tm_stm32f4_delay.c tm_stm32f4_timer_properties.c
  group Custom_TM_Libs/GPIO
    ../custom_libs/GPIO/: tm_stm32f4_gpio.c
  group Custom_TM_Libs/LCD
    ../custom_libs/LCD/: tm_stm32f4_hd44780.c tm_stm32f4_hd44780.h
  group Custom_TM_Libs/USART
    ../custom_libs/USART/: tm_stm32f4_usart.c
  group EWARM
    ../../../../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f4xx.s
  group STM32F4-Discovery
    ../../../../Utilities/STM32F4-Discovery/: stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
  group User
    ../: defines.h main.c stm32f4xx_it.c system_stm32f4xx.c
